Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project nummer
Time: 2018-06-28T10:20:30
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Jun 28 10:20:30 2018 * Host: B3ROBRAWR4428 * Database: C:\Users\LFI\AppData\Local\Temp\{7445C3D0-D64C-4DDB-8D40-3C0A4A7C4BC4}\ifc * Database version: 5507 * Database creation date: Thu Jun 28 10:20:27 2018 * Schema: IFC4 * Model: DataRepository.ifc * Model creation date: Thu Jun 28 10:20:28 2018 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Jun 28 10:20:28 2018 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project nummer
LongName: Project omschrijving; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Dimensions - S4R_Use_nominal_diameter: yes
Identity Data - Design Option: Main Model
Other - Category: Project Information; Client Name: Klant naam; Project Address: Enter address here; Project Issue Date: Aanvraag datum; Project Name: Project omschrijving; Project Number: Project nummer; Project Status: Project Status

# IfcBuildingStorey, V00
LongName: V00; Elevation: 0 mm
Other - Category: Levels; Family Name: Level; Family: Level: Floor Level; Family and Type: Level: Floor Level; Type: Level: Floor Level; Type Id: Level: Floor Level
Identity Data - Type Name: Floor Level; Building Story: yes; Name: V00; Structural: no
Graphics - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent: standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Constraints - Elevation: 0 mm; Elevation Base: Project Base Point
Dimensions - Computation Height: 0 mm

# IfcAirToAirHeatRecovery: 180_4-0 R+, VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Excellent_180_INT-EN:180_4-0 R+:1342469
In: V00
Type - Material: Color RAL 9016, Color RGB 062-062-062, Color RGB 162-162-162
Type - Dimensions - Depth: 301.996 mm; Height: 600 mm; Length: 559.993 mm
Type - Electrical - Loads - Nominal Voltage: 230 V
Type - Identity Data - Article Description: Heat recovery unit; Article Type: 180_4-0 R+; Content Supplier URL: www.MEPcontent.com; Copyright: © Stabiplan International BV; Custom: no; Description: Heat recovery unit; EMCS Version: 4.0; ETIM Article Class: EC011285; Family Version: 11.17; GTIN: 8718391155712; Manufacturer: Brink Climate Systems; Manufacturer Art. No.: 282001; Manufacturer URL: www.brinkclimatesystems.nl/downloads_renovent-excellent-180; MEPcontent Class: AIR_HEATER_HEAT_RECOVERY; Model: 180_4-0 R+; OmniClass Number: 23.75.70.17; OmniClass Title: Water Heated and Cooled Terminal Heating and Cooling Units; Product Line: Brink Climate Systems; Revit Version: 2017; Type Name: 180_4-0 R+; URL: www.stabiplan.com; Watermarked By: www.stabiplan.com
Type - Materials and Finishes - Glass: Color RGB 218-227-224; Grey: Color RGB 062-062-062; Light Grey: Color RGB 162-162-162; White: Color RAL 9016
Type - Other - Category: Mechanical Equipment; Buttons Position: 392 mm; Display Position: 380 mm; Drain Connector Position: 312 mm; Electric Connector Position: 37.5135 mm; Electric Connector Position Vetrical: 174 mm; Family Name: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Excellent_180_INT-EN; Horizontal P1: 79 mm; Horizontal P2: 75 mm; Horizontal P3: 168 mm; Horizontal P4: 125 mm; Vertical P1: 77 mm; Vertical P3: 213 mm
Type - Visibility - Visible Left: no; Visible Right: yes
Pset_ManufacturerTypeInformation - Manufacturer: Brink Climate Systems
Constraints - Offset: 0 mm
Dimensions - Area: 1.85282 m2; Volume: 0.101574 m3
Electrical - Loads - Apparent Load: 0 W; Nominal Current: 0 A
Identity Data - Design Option: Main Model; Mark: 4
Mechanical - Drain Fixture Units: 0; Heating Power: 0; System Classification: Supply Air,Return Air,Exhaust Air,Power,Sanitary
Mechanical - Flow - Exhaust Air Flow: 0 m3/s; Return Air Flow: 0 m3/s; Supply Air Flow 1: 0 m3/s; Supply Air Flow 2: 0 m3/s
Other - Family: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Excellent_180_INT-EN: 180_4-0 R+; Family and Type: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Excellent_180_INT-EN: 180_4-0 R+; Type: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Excellent_180_INT-EN: 180_4-0 R+; Type Id: VE_Air Heater_Heat Recovery_MEPcontent_Brink Climate Systems_Renovent Excellent_180_INT-EN: 180_4-0 R+; Wall Offset: 10 mm
Phasing - Phase Created: 3. Nieuwbouw
Visibility - Mounting Strip: yes; Service Area: no
